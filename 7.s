       AREA PROG7,CODE,READONLY
N RN 1
R RN 2
NDR RN 3
QUOTIENT RN 4
REMAINDER RN 5
DIVIDEND RN 6
DIVISOR RN 7
ENTRY
     LDR R8,=0X40000000
	 MOV N,#6
	 MOV R,#3
	 SUB NDR,N,R
	 MOV DIVIDEND,N
	 BL FACT
	 MOV N,DIVISOR
	 MOV DIVIDEND,R
	 BL FACT
	 MOV R,DIVISOR
	 MOV DIVIDEND,NDR
	 BL FACT
	 MOV NDR,DIVISOR
	 MUL R,NDR,R
	 MOV DIVISOR,R
	 MOV DIVIDEND,N
	 BL DIV
	 STR QUOTIENT,[R8]
GO   B GO  
FACT MOV DIVISOR,#1
LOOP2 MUL DIVISOR,DIVIDEND,DIVISOR
     SUBS DIVIDEND,DIVIDEND,#1
	 BNE LOOP2
	 BX LR
DIV 
LOOP3  SUBS DIVIDEND,DIVIDEND,DIVISOR
       ADDPL QUOTIENT,QUOTIENT,#1
	   BPL LOOP3
	   ADDMI REMAINDER,N,DIVISOR
	   BX LR
	   END
	AREA BCD,CODE,READONLY
RADIX RN 0
BYTE RN 8
NUMBYTES RN 3
UPPERNIBBLEMASK RN 4
LOWERNIBBLEMASK RN 5
UPPERNIBBLE RN 6
LOWERNIBBLE RN 7
RESULT RN 2
ENTRY MOV RADIX,#10
	  MOV LOWERNIBBLEMASK,#0X0F
	  MOV UPPERNIBBLEMASK,#0XF0
	  MOV RESULT,#0
	  MOV NUMBYTES,#4
	  LDR R1,=NUMBER
	  ADD R1,R1,NUMBYTES
	  SUBS R1,R1,#1
LOOP LDRB BYTE,[R1]
	 SUBS R1,R1,#1
	 AND LOWERNIBBLE,BYTE,LOWERNIBBLEMASK
	 AND UPPERNIBBLE,BYTE,UPPERNIBBLEMASK
	 LSR UPPERNIBBLE,#4
	 MLA RESULT,RADIX,RESULT,UPPERNIBBLE
	 MLA RESULT,RADIX,RESULT,LOWERNIBBLE
	 SUBS NUMBYTES,NUMBYTES,#1
	 BNE LOOP
GO B GO
NUMBER DCD 0X00000127
	END
	
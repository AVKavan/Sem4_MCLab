       AREA PROG5,CODE,READONLY
N RN 1
SUM RN 2
DIVISOR RN 3
QUOTIENT RN 4
REMAINDER RN 5
ENTRY
     LDR N,=12345
	 MOV SUM,#0
	 MOV QUOTIENT,#0
	 MOV DIVISOR,#10
	 MOV REMAINDER,#0
LOOP BL DIV
     ADD SUM,SUM,REMAINDER
	 CMP QUOTIENT,#0
	 MOVNE N,QUOTIENT
	 BNE LOOP
GO   B GO
DIV  MOV QUOTIENT,#0
LOOP2  SUBS N,N,DIVISOR
       ADDPL QUOTIENT,QUOTIENT,#1
	   BPL LOOP2
	   ADDMI REMAINDER,N,DIVISOR
	   BX LR
	   END
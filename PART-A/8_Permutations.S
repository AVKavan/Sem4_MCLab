        AREA PROG8,CODE,READONLY 
N RN 1
R RN 2
NDR RN 3
QUOTIENT RN 4
DIVISOR RN 5
DIVIDEND RN 6
REMAINDER RN 7
ENTRY 
     LDR R8,=0X40000000
     MOV N,#6
	 MOV R,#3
	 SUB NDR,N,R
	 MOV DIVIDEND,N
	 BL FACT
	 MOV N,DIVISOR
	 MOV DIVIDEND,NDR
	 BL FACT
	 MOV NDR,DIVISOR
	 MOV DIVIDEND,N
	 MOV DIVISOR,NDR
	 BL DIV
	 STR QUOTIENT,[R8]
GO   B GO
FACT MOV DIVISOR,#1
LOOP3 MUL DIVISOR,DIVIDEND,DIVISOR
      SUBS DIVIDEND,#1
	  BNE LOOP3
	  BX LR
DIV   
LOOP2 SUBS DIVIDEND,DIVIDEND,DIVISOR
      ADDPL QUOTIENT,QUOTIENT,#1
	  BPL LOOP2
	  ADDMI REMAINDER,DIVIDEND,DIVISOR
	  BX LR
	  END
	AREA PALIN,CODE,READONLY
DIVD RN 1
DIVS RN 3
COPY RN 4
MUL RN 5
Q RN 6
REM RN 7
RES RN 8
ENTRY MOV DIVS,#10
	  LDR DIVD,=12321
	  MOV RES,#0
	  MOV COPY,DIVD
	  MOV MUL,#10
LOOP BL DIV
	 MLA RES,MUL,RES,REM
	 CMP Q,#0
	 MOV DIVD,Q
	 BNE LOOP
	 CMP COPY,RES
	 MOVEQ R10,#1
	 MOVNE R10,#0
GO B GO
DIV MOV Q,#0
LOOP2 SUBS DIVD,DIVD,DIVS
	  ADDPL Q,Q,#1
	  BPL LOOP2
	  ADDMI REM,DIVD,DIVS
	  BX LR
	  END
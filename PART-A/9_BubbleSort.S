	AREA PROG,CODE,READONLY
ENTRY
			MOV R0,#13
			LDR R1,=NUMS
			LDR R2,=0x40000000
			
LOOP1		LDR R3,[R1],#4
			STR R3,[R2],#4
			SUBS R0,R0,#1
			BNE LOOP1
			
			MOV R12,#13
			LDR R11,=0x40000000
			
LOOP3		MOV R1,R11
			SUBS R12,R12,#1
			MOVNE R0,R12
			BEQ STOP
			
LOOP2		ADD R2,R1,#4
			LDR R3,[R1]
			LDR R4,[R2]
			CMP R3,R4
			STRPL R3,[R2]
			STRPL R4,[R1]
			ADD R1,R1,#4
			SUBS R0,R0,#1
			BNE LOOP2
			CMP R12,#0
			BNE LOOP3
			
STOP 		B STOP
NUMS 		DCD 20,19,18,17,16,15,14,13,12,11,10,9,8
			END